# IAR project os-app-test.ewp, settings and files
configuration Debug (AVR, debug)
  General.LCHeapSize: 0x10
  General.SCCStackSize: 650
  General.SCRStackSize: 650
  General.LCTinyHeapSize: 0x10
  General.LCNearHeapSize: 0x20
  General.LCFarHeapSize: 0x1000
  General.LCHugeHeapSize: 0x1000
  ICCAVR.CCDefines: ENABLE_BIT_DEFINITIONS
  ICCAVR.newCCIncludePaths: C:\Documents and Settings\Administrator\桌面\uc-app-test\includes; C:\Documents and Settings\Administrator\桌面\uc-app-test\driver_include; D:\Work\uc-app-test\includes; D:\Work\uc-app-test\driver_include
  ICCAVR.CCStdIncludePaths: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\CLIB\
  XLINK.XclFile: $TOOLKIT_DIR$\src\template\cfgm128.xcl
configuration Release (AVR)
  as the first configuration, except:
  General.SCCStackSize: 400
  General.SCRStackSize: 400
  ICCAVR.newCCIncludePaths: C:\Documents and Settings\Administrator\桌面\uc-app-test\includes
  group BSP
    bsp/: bsp.c
  group cpu
    cpu/: os_cpu_a.asm os_cpu_c.c
  group driver
    driver/: keyboard.c LCD.c
    includes/: keyboard.h LCD.h
  group include
    includes/: app_cfg.h bitmap.c bsp.h driver_func.h includes.h os_cfg.h os_cpu.h ucos_ii.h
  group test-app
    app/: app.c app_isr.asm app_vect.asm
  group uc/os2.83
    os2.83/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c
